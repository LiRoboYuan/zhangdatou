# Keil uVision project project.uvprojx, settings and files
target Project (6150000::V6.15::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,__TARGET_FPU_VFP,USE_USBHS,GD32F407,USE_EMBEDDED_PHY
  c include: ..\..\app;..\..\bsp;..\..\libraries\CMSIS\GD\GD32F4xx\Include;..\..\libraries\CMSIS\GD\GD32F4xx;..\..\libraries\GD32F4xx_standard_peripheral\Include;..\..\libraries\CMSIS;..\..\libraries\CMSIS\GD\GD32F4xx\Source\ARM;..\..\board;..\..\module\soft_timer;..\..\module\ringbuffer;..\..\module\buzzer;..\..\bsp\uart;..\..\bsp\moto;..\..\bsp\led;..\..\bsp\airsac;..\..\bsp\power;..\..\bsp\bsp_switch;..\..\bsp\PID;..\..\bsp\flash_operate;..\..\bsp\mx_sensor;..\..\bsp\usb;..\..\bsp\master_serial;..\..\bsp\height_and_weight;..\..\bsp\can;..\..\bsp\auto_adaptation;..\..\module\auto_adaptation_math
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\project.sct
  group APP
    ../../app/: main.c
  group STD_Driver
    ../../libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group STARTUP
    ../../libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group MODULE
    ../../module/soft_timer/: soft_timer.c
    ../../module/ringbuffer/: ringbuffer.c circular_buffer.c priv_malloc.c
    ../../bsp/PID/: PID_base.c PID_moto_control.c
    ../../module/auto_adaptation_math/: auto_adaptation_math.c
  group CMSIS
    ../../libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Board
    ../../board/: board.c
  group BSP
    ../../bsp/uart/: bsp_uart.c bsp_uart_ringbuffer.c
    ../../bsp/moto/: bsp_moto.c bsp_encoder.c moto_control.c
    ../../bsp/led/: bsp_led.c
    ../../bsp/airsac/: lin.c bsp_airsac.c
    ../../bsp/power/: bsp_power_check.c
    ../../bsp/bsp_switch/: bsp_switch.c
    ../../bsp/flash_operate/: bsp_flash_operate.c
    ../../bsp/master_serial/: bsp_master_serial.c bsp_master_serial_core.c
    ../../bsp/mx_sensor/: bsp_mx_sensor.c
    ../../bsp/usb/: USBHS_cdc_acm.lib
    ../../bsp/height_and_weight/: height_weight.c
    ../../bsp/can/: can.c bsp_can.c
    ../../bsp/auto_adaptation/: auto_adaptation.c
  group DOC
    ../../: README.md
